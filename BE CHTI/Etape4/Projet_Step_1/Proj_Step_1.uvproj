# Keil uVision project Proj_Step_1.uvproj, settings and files
target Cible_STM103RB (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Proj_Step_1
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c include: .\Lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Sources
    ./Sources/: principal.c bruitverre.asm Trigo.asm Signal.asm M2.s Somme.s Tempo.s
  group Lib
    ./Lib/: gassp72.lib
  group Sys
    ./Systeme/: startup-rvds.s
target Cible_Simulateur (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: Proj_Step_1
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c include: .\Lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
