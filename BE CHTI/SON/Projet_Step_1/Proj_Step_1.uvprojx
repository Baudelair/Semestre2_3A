# Keil uVision project Proj_Step_1.uvprojx, settings and files
target Cible_STM103RB (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Proj_Step_1
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c include: .\Lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Sources
    ./Sources/: principal.c Tempo.s bruitverre.asm
  group Lib
    ./Lib/: gassp72.lib
  group Sys
    ./Systeme/: startup-rvds.s
target Cible_Simulateur (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: Proj_Step_1
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c include: .\Lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.0.1
